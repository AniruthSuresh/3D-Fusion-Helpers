Commit message: still not picking up the cube

File: lite-6-sim-teleop/urdf-data/cube/cube.urdf (robot description, URDF)
Before this commit: robot cube, 1 links, 0 joints
Links:
- link baseLink: mass 1.0 -> 0.5; geometry collision box size=0.03 0.03 0.03; visual box size=0.03 0.03 0.03
