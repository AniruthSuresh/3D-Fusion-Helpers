Commit message: nitin changes on a new branch

File: ur5-object-picking/urdf/ur5_robotiq_85.urdf (robot description, URDF)
Before this commit: robot ur5_robotiq_85, 20 links, 19 joints
Links:
- link left_inner_finger_pad: mass 1. -> 5.0
- link right_inner_finger_pad: mass 1 -> 5.0
